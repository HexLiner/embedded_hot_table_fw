# IAR project hot_table.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F070F6 ST STM32F070F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F070F6; STM32F070x6; DEBUG
  ICCARM.CCIncludePath2: src; lib\; lib\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hot_table.hex
  ILINK.IlinkOutputFile: hot_table.out
  ILINK.IlinkIcfFile: src\stm32f070x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750VB; STM32H750xx; ERROR_ALLOW_LONG_STRINGS
  ICCARM.CCIncludePath2: src; lib\ta_fw\; lib\ta_fw\cmsis
  OBJCOPY.OOCOutputFile: MR_MI_601.hex
  prebuild: "build_revision.bat" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: MR_MI_601.out
  ILINK.IlinkIcfFile: src\stm32h750xx_flash.icf
configuration Debug_HW_V_1_1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750VB; STM32H750xx; DEBUG; ERROR_ALLOW_LONG_STRINGS; HW_V_1_1
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: MR_MI_601.hex
  prebuild: "build_revision.bat" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: MR_MI_601.out
  ILINK.IlinkIcfFile: src\stm32h750xx_flash.icf
configuration Release_HW_V_1_1 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750VB; STM32H750xx; ERROR_ALLOW_LONG_STRINGS; HW_V_1_1
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: MR_MI_601.hex
  prebuild: "build_revision.bat" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: MR_MI_601.out
  ILINK.IlinkIcfFile: src\stm32h750xx_flash.icf
  group lib/cmsis
    lib/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f070x6.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group lib/common
    lib/common/: error.c error.h lib_base.h mcu.h
  group lib/hal/gpio
    lib/hal/gpio/: gpio.c gpio.h
  group lib/hal/sysclk
    lib/hal/sysclk/: sysclk.h sysclk_stm32f070f6.c sysclk_stm32f070f6.h
  group lib/hal/systimer
    lib/hal/systimer/: systimer.c systimer.h
  group lib/startup
    lib/startup/: startup_stm32f070x6.s
  group src
    src/: irq_handlers.c irq_handlers.h main.c mcu_clock.c mcu_clock.h
