<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hot_table.ewp</path>
    </project>
    <batchBuild />
</workspace>
